# Keil uVision project project.uvprojx, settings and files
target GD32F4XX (6160000::V6.16::ARMCLANG)
  device: GD32F405VG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32F405
  c include: ..\components\GD32F4xx_Firmware_Library\Firmware\CMSIS\GD\GD32F4xx\Include;..\components\GD32F4xx_Firmware_Library\Firmware\CMSIS;..\components\GD32F4xx_Firmware_Library\Firmware\CMSIS\GD\GD32F4xx\Source\ARM;..\components\GD32F4xx_Firmware_Library\Firmware\GD32F4xx_standard_peripheral\Include;..\src\include;..\components\freertos\Source\include;..\components\freertos\Source\portable\GCC\ARM_CM4F;..\components\common\Include;..\components\driver\gd32f4xx\on_chip\include;..\components\driver\gd32f4xx\ext_chip\include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../src/: app_main.c gd32f4xx_it.c
  group stp
    ../components/gd32f4xx_firmware_library/Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
    ../components/gd32f4xx_firmware_library/Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../components/gd32f4xx_firmware_library/Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f405_425.s
  group freertos/gd32/driver
    ../components/common/: fc_main.c
    ../components/driver/gd32f4xx/on_chip/: fd_spi.c fd_uart.c
    ../components/driver/gd32f4xx/ext_chip/: fd_w5500.c
  group freertos/kernel
    ../components/freertos/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/port
    ../components/freertos/Source/portable/GCC/ARM_CM4F/: port.c
    ../components/freertos/Source/portable/MemMang/: heap_4.c
